Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.229_LIXEIRA_QUADRAT-9_25-LITROS_INOX.IFC
Time: 2023-04-04T10:44:00
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.229_LIXEIRA_QUADRAT-9_25-LITROS_INOX
In: Default Storey
Material: Steel
